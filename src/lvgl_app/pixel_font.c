#include "pixel_font.h"

#include <string.h>

typedef struct {
  uint8_t ch;
  uint8_t row[7];
} PixelGlyph;

// Five useful columns in each row, bit 4 on the left. The face deliberately
// stays compact and mechanical: it is dashboard instrumentation, not a
// general-purpose UI font.
static const PixelGlyph glyphs[] = {
    {'!', {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04}},
    {'%', {0x19, 0x1A, 0x04, 0x08, 0x0B, 0x13, 0x00}},
    {'(', {0x02, 0x04, 0x08, 0x08, 0x08, 0x04, 0x02}},
    {')', {0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0x08}},
    {'+', {0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00}},
    {',', {0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08}},
    {'-', {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00}},
    // Half-advance glyph, so its ink sits in column 1 of the three it occupies.
    {'.', {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08}},
    {'/', {0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10}},
    {'0', {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}},
    {'1', {0x04, 0x0C, 0x14, 0x04, 0x04, 0x04, 0x1F}},
    {'2', {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}},
    {'3', {0x1E, 0x01, 0x01, 0x0E, 0x01, 0x01, 0x1E}},
    {'4', {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}},
    {'5', {0x1F, 0x10, 0x10, 0x1E, 0x01, 0x01, 0x1E}},
    {'6', {0x0E, 0x10, 0x10, 0x1E, 0x11, 0x11, 0x0E}},
    {'7', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
    {'8', {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}},
    {'9', {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x01, 0x0E}},
    {':', {0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00}},
    {'<', {0x02, 0x04, 0x08, 0x10, 0x08, 0x04, 0x02}},
    {'=', {0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00}},
    {'>', {0x08, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08}},
    {'?', {0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04}},
    {'A', {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'B', {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E}},
    {'C', {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E}},
    {'D', {0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E}},
    {'E', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F}},
    {'F', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}},
    {'G', {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F}},
    {'H', {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'I', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1F}},
    {'J', {0x01, 0x01, 0x01, 0x01, 0x11, 0x11, 0x0E}},
    {'K', {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}},
    {'L', {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F}},
    {'M', {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}},
    {'N', {0x11, 0x19, 0x19, 0x15, 0x13, 0x13, 0x11}},
    {'O', {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'P', {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}},
    {'Q', {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D}},
    {'R', {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}},
    {'S', {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E}},
    {'T', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'V', {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04}},
    {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x1B, 0x11}},
    {'X', {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11}},
    {'Y', {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04}},
    {'Z', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}},
    {'[', {0x0E, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0E}},
    {']', {0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x0E}},
    {'_', {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F}},
    {0xB0, {0x06, 0x09, 0x09, 0x06, 0x00, 0x00, 0x00}},
};

typedef struct {
  uint8_t scale;
} PixelFontDsc;

// Widest glyph in use is 5*14 x 7*14, which packs into 858 bytes at 1 bpp.
static uint8_t bitmap_buffer[858];

static uint8_t normalize_char(uint32_t c) {
  if (c >= 'a' && c <= 'z') return (uint8_t)(c - 'a' + 'A');
  switch (c) {
    case 0x00C4: case 0x00C5: case 0x00C0: case 0x00C1: case 0x00C2:
    case 0x00E4: case 0x00E5: case 0x00E0: case 0x00E1: case 0x00E2: return 'A';
    case 0x00D6: case 0x00D2: case 0x00D3: case 0x00D4:
    case 0x00F6: case 0x00F2: case 0x00F3: case 0x00F4: case 0x03A9: return 'O';
    case 0x00DC: case 0x00D9: case 0x00DA: case 0x00DB:
    case 0x00FC: case 0x00F9: case 0x00FA: case 0x00FB: return 'U';
    case 0x00C9: case 0x00C8: case 0x00CA: case 0x00CB:
    case 0x00E9: case 0x00E8: case 0x00EA: case 0x00EB: return 'E';
    case 0x00CD: case 0x00CC: case 0x00CE: case 0x00CF:
    case 0x00ED: case 0x00EC: case 0x00EE: case 0x00EF: return 'I';
    case 0x00D1: case 0x00F1: return 'N';
    case 0x00C7: case 0x00E7: return 'C';
    case 0x00DF: return 'B';
    case 0x00B0: return 0xB0;
    default: return c < 128 ? (uint8_t)c : '?';
  }
}

static const uint8_t *glyph_rows(uint32_t letter) {
  const uint8_t c = normalize_char(letter);
  for (uint32_t i = 0; i < sizeof(glyphs) / sizeof(glyphs[0]); i++) {
    if (glyphs[i].ch == c) return glyphs[i].row;
  }
  for (uint32_t i = 0; i < sizeof(glyphs) / sizeof(glyphs[0]); i++) {
    if (glyphs[i].ch == '?') return glyphs[i].row;
  }
  return NULL;
}

static bool pixel_get_glyph_dsc(const lv_font_t *font, lv_font_glyph_dsc_t *out, uint32_t letter,
                                uint32_t letter_next) {
  (void)letter_next;
  const PixelFontDsc *dsc = (const PixelFontDsc *)font->dsc;
  const uint8_t scale = dsc->scale;
  memset(out, 0, sizeof(*out));
  // The period carries half an advance: decimal readouts read as one number
  // rather than two, and a four-character value buys back a whole cell of room.
  // Its box stays 5 cells wide, but the empty columns are transparent at 1 bpp.
  out->adv_w = (letter == ' ' || letter == '.') ? 3 * scale : 6 * scale;
  if (letter != ' ') {
    out->box_w = 5 * scale;
    out->box_h = 7 * scale;
    out->bpp = 1;
  }
  return true;
}

static const uint8_t *pixel_get_glyph_bitmap(const lv_font_t *font, uint32_t letter) {
  if (letter == ' ') return NULL;
  const PixelFontDsc *dsc = (const PixelFontDsc *)font->dsc;
  const uint8_t scale = dsc->scale;
  const uint8_t *rows = glyph_rows(letter);
  if (!rows) return NULL;
  const uint16_t w = 5 * scale;
  const uint16_t h = 7 * scale;
  const uint16_t bytes = (uint16_t)((w * h + 7) / 8);
  memset(bitmap_buffer, 0, bytes);
  for (uint8_t sy = 0; sy < 7; sy++) {
    for (uint8_t sx = 0; sx < 5; sx++) {
      if ((rows[sy] & (0x10 >> sx)) == 0) continue;
      for (uint8_t yy = 0; yy < scale; yy++) {
        for (uint8_t xx = 0; xx < scale; xx++) {
          const uint32_t bit = (uint32_t)(sy * scale + yy) * w + sx * scale + xx;
          bitmap_buffer[bit >> 3] |= (uint8_t)(0x80 >> (bit & 7));
        }
      }
    }
  }
  return bitmap_buffer;
}

static const PixelFontDsc dsc8 = {1};
static const PixelFontDsc dsc16 = {2};
static const PixelFontDsc dsc24 = {3};
static const PixelFontDsc dsc32 = {4};
static const PixelFontDsc dsc64 = {8};
static const PixelFontDsc dsc80 = {10};
static const PixelFontDsc dsc112 = {14};

#define PIXEL_FONT(name, scale, descriptor)       \
  const lv_font_t name = {                        \
      .get_glyph_dsc = pixel_get_glyph_dsc,       \
      .get_glyph_bitmap = pixel_get_glyph_bitmap, \
      .line_height = 8 * (scale),                  \
      .base_line = (scale),                        \
      .subpx = LV_FONT_SUBPX_NONE,                 \
      .underline_position = -(scale),              \
      .underline_thickness = (scale),              \
      .dsc = &(descriptor),                        \
      .fallback = NULL,                            \
  }

PIXEL_FONT(lv_font_pixel_8, 1, dsc8);
PIXEL_FONT(lv_font_pixel_16, 2, dsc16);
PIXEL_FONT(lv_font_pixel_24, 3, dsc24);
PIXEL_FONT(lv_font_pixel_32, 4, dsc32);
PIXEL_FONT(lv_font_pixel_64, 8, dsc64);
PIXEL_FONT(lv_font_pixel_80, 10, dsc80);
PIXEL_FONT(lv_font_pixel_112, 14, dsc112);
